#include "ui.h"

#include <Adafruit_GFX.h>
#include <Fonts/FreeSans9pt7b.h>
#include <Fonts/FreeSans12pt7b.h>
#include <Fonts/FreeSansBold12pt7b.h>
#include <cstring>
#include <cstdio>
#include <cstdarg>

const char* KB_ROWS[3][3] = {
  { "qwertyuiop", "asdfghjkl",  "zxcvbnm" },
  { "йцукенгшщз", "фывапролдж", "ячсмитьбъ" },
  { "1234567890", ".,:;!?@#&*", "+-=/_\"'()" },
};

uint16_t lerpColor(uint16_t c1, uint16_t c2, uint8_t t) {
    int r1=(c1>>11)&31, g1=(c1>>5)&63, b1=c1&31;
    int r2=(c2>>11)&31, g2=(c2>>5)&63, b2=c2&31;
    return ((r1+((r2-r1)*t)/255)<<11) | ((g1+((g2-g1)*t)/255)<<5) | (b1+((b2-b1)*t)/255);
}

void osdPrintf(int16_t x, int16_t y, uint8_t size, uint16_t color, const char* fmt, ...) {
    char buf[128]; va_list ap; va_start(ap, fmt);
    vsnprintf(buf, sizeof(buf), fmt, ap); va_end(ap);
    disp->setTextColor(color); disp->setTextSize(1);
    if (size == 1)      { disp->setFont(nullptr);         disp->setCursor(x, y); }
    else if (size == 2) { disp->setFont(&FreeSans9pt7b);  disp->setCursor(x, y + 12); }
    else                { disp->setFont(&FreeSans12pt7b); disp->setCursor(x, y + 16); }
    disp->print(buf);
    disp->setFont(nullptr);
}

void wAppBar(const char* title) {
    for (int y = 0; y < 26; y++)
        disp->fillRect(0, y, 320, 1, lerpColor(NEON_CYAN, NEON_BLUE, y * 10));
    disp->setFont(&FreeSansBold12pt7b); disp->setTextColor(WHITE); disp->setTextSize(1);
    disp->setCursor(8, 19); disp->print(title);
    disp->setFont(nullptr);
    disp->fillRect(0, 26, 320, 1, NEON_MAG);
}

void wCard(int x, int y, int w, int h) {
    disp->fillRoundRect(x, y, w, h, 10, NEON_CARD);
    disp->drawRoundRect(x, y, w, h, 10, NEON_DIM);
    disp->drawLine(x + 8, y + 1, x + w - 8, y + 1, 0x9CF3);
}

void wPill(int x, int y, int w, int h, uint16_t col, const char* lbl) {
    disp->fillRoundRect(x, y + 2, w, h, h / 2, 0x0000);
    disp->fillRoundRect(x, y, w, h, h / 2, col);
    disp->setFont(&FreeSans9pt7b); disp->setTextColor(WHITE); disp->setTextSize(1);
    int len = strlen(lbl) * 7;
    disp->setCursor(x + w / 2 - len / 2, y + h / 2 + 4); disp->print(lbl);
    disp->setFont(nullptr);
}

void wFab(int cx, int cy, int r, uint16_t col, const char* lbl) {
    disp->fillCircle(cx, cy + 2, r, 0x0000);
    disp->fillCircle(cx, cy, r, col);
    disp->drawCircle(cx, cy, r, WHITE);
    disp->setFont(&FreeSans9pt7b); disp->setTextColor(WHITE); disp->setTextSize(1);
    disp->setCursor(cx - 4, cy + 5); disp->print(lbl);
    disp->setFont(nullptr);
}

void wChip(int x, int y, const char* lbl, bool on, uint16_t col) {
    disp->fillRoundRect(x, y, 72, 16, 8, on ? col : 0x1082);
    disp->drawRoundRect(x, y, 72, 16, 8, on ? WHITE : NEON_DIM);
    disp->setTextColor(on ? BLACK : NEON_TXT); disp->setTextSize(1); disp->setFont(nullptr);
    disp->setCursor(x + 24, y + 4); disp->print(lbl);
    disp->fillCircle(x + 10, y + 8, 4, on ? BLACK : NEON_RED);
}

void wWifiIcon() {
    int rssi = wifiOK ? WiFi.RSSI() : -120;
    int bars = (rssi >= -50) ? 4 : (rssi >= -60) ? 3 : (rssi >= -70) ? 2 : (rssi >= -80) ? 1 : 0;
    for (int i = 0; i < 4; i++) {
        int h = 4 + i * 3, x = 320 - 24 + i * 5;
        disp->fillRect(x, 20 - h, 3, h, (i < bars) ? NEON_LIME : NEON_DIM);
    }
}

static const uint8_t SEG7[10] = {0x3F,0x06,0x5B,0x4F,0x66,0x6D,0x7D,0x07,0x7F,0x6F};
void wSegChar(int x, int y, int u, char c, uint16_t col) {
    uint8_t m = 0;
    if (c >= '0' && c <= '9') m = SEG7[c - '0'];
    else if (c == '-') m = 0x40;
    else if (c == '.') { disp->fillRect(x + u, y + 7 * u, 2 * u, 2 * u, col); return; }
    else return;
    if (m & 0x01) disp->fillRect(x + u, y, 4 * u, u, col);
    if (m & 0x02) disp->fillRect(x + 5 * u, y + u, u, 3 * u, col);
    if (m & 0x04) disp->fillRect(x + 5 * u, y + 5 * u, u, 3 * u, col);
    if (m & 0x08) disp->fillRect(x + u, y + 8 * u, 4 * u, u, col);
    if (m & 0x10) disp->fillRect(x, y + 5 * u, u, 3 * u, col);
    if (m & 0x20) disp->fillRect(x, y + u, u, 3 * u, col);
    if (m & 0x40) disp->fillRect(x + u, y + 4 * u, 4 * u, u, col);
}
void wBigNumber(int x, int y, int u, const char* s, uint16_t col) {
    int cx = x;
    for (const char* p = s; *p; p++) {
        wSegChar(cx, y, u, *p, col);
        cx += (*p == '.') ? 4 * u : 8 * u;
    }
}

static const uint8_t cyrFont[32][7] = {
{0x00,0x0E,0x02,0x0E,0x12,0x0E,0x00},{0x00,0x1E,0x08,0x0E,0x12,0x0E,0x00},
{0x00,0x1E,0x12,0x1E,0x12,0x1E,0x00},{0x00,0x1E,0x08,0x08,0x08,0x08,0x00},
{0x00,0x0E,0x12,0x12,0x12,0x1E,0x00},{0x00,0x0E,0x12,0x1E,0x10,0x0E,0x00},
{0x00,0x12,0x12,0x0E,0x12,0x12,0x00},{0x00,0x1E,0x02,0x0C,0x02,0x1E,0x00},
{0x00,0x12,0x12,0x16,0x1A,0x12,0x00},{0x0E,0x12,0x12,0x16,0x1A,0x12,0x00},
{0x00,0x12,0x14,0x18,0x14,0x12,0x00},{0x00,0x0C,0x12,0x12,0x12,0x12,0x00},
{0x00,0x12,0x1A,0x1A,0x12,0x12,0x00},{0x00,0x12,0x12,0x1E,0x12,0x12,0x00},
{0x00,0x0E,0x12,0x12,0x12,0x0E,0x00},{0x00,0x1E,0x12,0x12,0x12,0x12,0x00},
{0x00,0x1C,0x12,0x1C,0x10,0x10,0x00},{0x00,0x0E,0x12,0x10,0x12,0x0E,0x00},
{0x00,0x1E,0x08,0x08,0x08,0x08,0x00},{0x00,0x12,0x12,0x0C,0x04,0x08,0x00},
{0x00,0x04,0x0E,0x12,0x0E,0x04,0x00},{0x00,0x12,0x12,0x0E,0x12,0x12,0x00},
{0x00,0x12,0x12,0x12,0x12,0x1E,0x02},{0x00,0x12,0x12,0x0E,0x02,0x02,0x00},
{0x00,0x15,0x15,0x15,0x15,0x1F,0x00},{0x00,0x15,0x15,0x15,0x15,0x1F,0x01},
{0x00,0x18,0x08,0x1E,0x12,0x1E,0x00},{0x00,0x12,0x12,0x1E,0x12,0x1E,0x00},
{0x00,0x10,0x10,0x1E,0x12,0x1E,0x00},{0x00,0x0E,0x02,0x06,0x02,0x0E,0x00},
{0x00,0x12,0x13,0x1F,0x13,0x12,0x00},{0x00,0x0E,0x02,0x0E,0x12,0x0E,0x00},
};
static const uint8_t cyrUpFont[32][7] = {
{0x0E,0x12,0x12,0x1E,0x12,0x12,0x00},{0x1E,0x08,0x08,0x1E,0x12,0x12,0x1E},
{0x1E,0x12,0x12,0x1E,0x12,0x12,0x1E},{0x1E,0x08,0x08,0x08,0x08,0x08,0x00},
{0x0E,0x12,0x12,0x12,0x12,0x1E,0x00},{0x1E,0x12,0x12,0x1E,0x10,0x10,0x1E},
{0x12,0x12,0x0E,0x0E,0x0E,0x12,0x12},{0x1E,0x02,0x02,0x0E,0x02,0x02,0x1E},
{0x12,0x12,0x16,0x1A,0x12,0x12,0x12},{0x0E,0x12,0x12,0x16,0x1A,0x12,0x12},
{0x12,0x14,0x18,0x14,0x12,0x12,0x12},{0x0E,0x12,0x12,0x12,0x12,0x12,0x12},
{0x12,0x1A,0x1A,0x12,0x12,0x12,0x12},{0x12,0x12,0x12,0x1E,0x12,0x12,0x12},
{0x0E,0x12,0x12,0x12,0x12,0x12,0x0E},{0x1E,0x12,0x12,0x12,0x12,0x12,0x12},
{0x1E,0x12,0x12,0x1E,0x10,0x10,0x10},{0x0E,0x12,0x10,0x10,0x10,0x12,0x0E},
{0x1E,0x08,0x08,0x08,0x08,0x08,0x08},{0x12,0x12,0x12,0x0E,0x02,0x02,0x0C},
{0x04,0x0E,0x12,0x12,0x0E,0x04,0x04},{0x12,0x12,0x0E,0x0E,0x0E,0x12,0x12},
{0x12,0x12,0x12,0x12,0x12,0x1E,0x02},{0x12,0x12,0x12,0x0E,0x02,0x02,0x02},
{0x15,0x15,0x15,0x15,0x15,0x15,0x1F},{0x15,0x15,0x15,0x15,0x15,0x1F,0x01},
{0x18,0x08,0x08,0x1E,0x12,0x12,0x1E},{0x10,0x10,0x1E,0x12,0x12,0x12,0x1E},
{0x10,0x10,0x1E,0x12,0x12,0x12,0x1E},{0x0E,0x02,0x02,0x06,0x02,0x02,0x0E},
{0x12,0x12,0x13,0x1F,0x13,0x12,0x12},{0x0E,0x12,0x12,0x0E,0x12,0x12,0x0E},
};

void drawCyr(int x, int y, uint16_t cp, uint16_t color, uint8_t scale) {
    const uint8_t* g = NULL;
    if (cp >= 0x430 && cp <= 0x44F) g = cyrFont[cp - 0x430];
    else if (cp >= 0x410 && cp <= 0x42F) g = cyrUpFont[cp - 0x410];
    if (!g) return;
    for (int r = 0; r < 7; r++)
        for (int b = 0; b < 5; b++)
            if (g[r] & (1 << (4 - b)))
                disp->fillRect(x + b * scale, y + r * scale, scale, scale, color);
}

void drawUtf8(int x, int y, const String& s, uint16_t color, uint8_t scale) {
    int cx = x; size_t i = 0;
    disp->setTextColor(color); disp->setTextSize(1);
    if (scale == 1) disp->setFont(nullptr);
    else            disp->setFont(&FreeSans9pt7b);
    while (i < s.length()) {
        uint8_t c = s[i];
        if (c < 0x80) {
            disp->setCursor(cx, y + (scale == 1 ? 0 : 12));
            disp->print((char)c);
            cx = disp->getCursorX(); i++;
        } else {
            uint16_t cp = ((c & 0x1F) << 6) | (s[i + 1] & 0x3F);
            drawCyr(cx, y + (scale == 1 ? 0 : 2), cp, color, scale);
            cx += 6 * scale; i += 2;
        }
    }
    disp->setFont(nullptr);
}

String utf8At(const String& s, int idx) {
    int n = 0; size_t i = 0;
    while (i < s.length()) {
        if (n == idx) { uint8_t c = s[i]; return (c < 0x80) ? s.substring(i, i + 1) : s.substring(i, i + 2); }
        i += (s[i] < 0x80) ? 1 : 2; n++;
    }
    return "";
}